# Keil uVision project dummy.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy +hex
  BeforeCompile: .\scripts\_before_compile.bat #X #E
  BeforeMake: .\scripts\_before_build_dump.bat #X #P "Target 1"
  AfterMake: .\scripts\_after_build.bat #X #P
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --feedback=unused --cpp11
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\ini\stack_relocation.sct
  link misc: --feedback=unused --diag_suppress 6329 --diag_suppress 6314
  group main
    ./src/Main/: main.cpp
  group mcu_support_package
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
    ./src/mcu_support_package/: system_stm32f10x.c
